# Keil uVision project BEST_USE.uvprojx, settings and files
target BEST_USE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BEST_USE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Core/MY_DSP/MY_5351;../Core/MY_DSP/MY_Shuma;../Core/MY_DSP/MY_DDS;..\Core\MY_DSP\MY_Uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MY_DSP
    ../Core/MY_DSP/MY_5351/: si5351.c si5351.h si5351_asserts.h si5351_errors.h
    ../Core/MY_DSP/MY_Shuma/: TM1637.c TM1637.h delay.c delay.h
    ../Core/MY_DSP/MY_DDS/: ad9959.c ad9959.h
    ../Core/MY_DSP/MY_262/: MAX262.c MAX262.h
    ../Core/MY_DSP/MY_Uart/: frequency_control.c frequency_control.h ZPN_Hmi.c ZPN_Hmi.h ZPN_Hmi_Pack.c ZPN_Hmi_Pack.h ZPN_Uart.c ZPN_Uart.h ZPN_Uart_Config.h ZPN_Uart_Vofa.c ZPN_Uart_Vofa.h amplitude_control.c amplitude_control.h
    ../Core/MY_DSP/MY_DDS_FUN/: 9959_scan.c
    ../Core/MY_DSP/MY_FFT/: Phase.c WindowFunction.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
